FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0002-Allow-for-setting-password-in-clear-text.patch"
